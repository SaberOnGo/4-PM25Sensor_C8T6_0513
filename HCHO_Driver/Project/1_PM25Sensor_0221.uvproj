# Keil uVision project 1_PM25Sensor_0221.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: 1_PM25Sensor_0221 +hex
  c flags: Optim=3 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD,
  c include: ..\Library\inc;..\System\CMSIS;..\System\startup;..\Driver\inc;..\OS\inc;..\User\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Library
    ../Library/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_pwr.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_spi.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dma.c
    ../Library/inc/: misc.h stm32f10x_gpio.h stm32f10x_fsmc.h stm32f10x_rcc.h
  group User
    ../User/src/: main.c stm32f10x_it.c Application.c
    ../Driver/src/: TimerManager.c
  group Driver
    ../Driver/src/: delay.c LCD1602_Drv.c PM25Sensor.c Uart_Drv.c DHT11.c
    ../OS/src/: os_global.c os_timer.c
  group CMSIS
    ../System/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group startup
    ../System/startup/: startup_stm32f10x_md.s
